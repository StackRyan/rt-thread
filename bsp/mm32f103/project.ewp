# IAR project project.ewp, settings and files
configuration rt-thread (ARM, debug)
  General.OGChipSelectEditMenu: MM32F103xB MindMotion MM32F103xB
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: __RTTHREAD__; USE_STDPERIPH_DRIVER
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\..\components\libc\compilers\common\none-gcc; Libraries\MM32F103\Source; ..\..\include; Libraries\CMSIS\KEIL_CORE; drivers; ..\..\components\libc\compilers\common; ..\..\examples\utest\testcases\kernel; .; applications; Libraries\MM32F103\HAL_lib\inc; Libraries\MM32F103\Include; ..\..\libcpu\arm\cortex-m3; ..\..\components\drivers\include; ..\..\libcpu\arm\common; ..\..\components\finsh
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ../../../rtthread.bin
  ILINK.IlinkOutputFile: rtthread.out
  ILINK.IlinkIcfFile: drivers\linker_scripts\link.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 0
  ICCARM.CCOptLevel: 3
  group Applications
    applications/: main.c
  group CPU
    ../../libcpu/arm/common/: div0.c backtrace.c showmem.c
    ../../libcpu/arm/cortex-m3/: context_iar.S cpuport.c
  group DeviceDrivers
    ../../components/drivers/misc/: pin.c
    ../../components/drivers/serial/: serial.c
    ../../components/drivers/src/: completion.c ringblk_buf.c workqueue.c pipe.c dataqueue.c ringbuffer.c waitqueue.c
  group Drivers
    drivers/: drv_gpio.c drv_uart.c board.c
  group finsh
    ../../components/finsh/: finsh_vm.c msh.c finsh_parser.c cmd.c finsh_node.c shell.c finsh_var.c finsh_compiler.c finsh_heap.c finsh_ops.c finsh_error.c finsh_token.c finsh_init.c
  group Kernel
    ../../src/: thread.c mempool.c scheduler.c device.c object.c idle.c components.c clock.c irq.c memheap.c mem.c kservice.c timer.c ipc.c
  group libc
    ../../components/libc/compilers/common/: time.c
  group Libraries
    Libraries/MM32F103/Source/: system_MM32F103.c
    Libraries/MM32F103/HAL_lib/src/: HAL_dma.c HAL_pwr.c HAL_crc.c HAL_rtc.c HAL_rcc.c HAL_exti.c HAL_iwdg.c HAL_adc.c HAL_tim.c HAL_gpio.c HAL_uart.c HAL_can.c HAL_spi.c HAL_i2c.c HAL_wwdg.c HAL_bkp.c HAL_misc.c HAL_flash.c
    Libraries/MM32F103/Source/IAR_StartAsm/: startup_MM32F103.s
