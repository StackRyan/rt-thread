# Keil uVision project project.uvprojx, settings and files
target rtthread (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: MM32F103RBT MindMotion
  pack: MindMotion.MM32F103x8xB_DFP.1.4.7
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: rtthread +hex
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 OneElfS=1 uC99=1
  c define: USE_STDPERIPH_DRIVER, __RTTHREAD__, __CLK_TCK=RT_TICK_PER_SECOND
  c include: applications;.;..\..\libcpu\arm\common;..\..\libcpu\arm\cortex-m3;..\..\components\drivers\include;..\..\components\drivers\include;..\..\components\drivers\include;drivers;..\..\components\finsh;.;..\..\include;..\..\components\libc\compilers\common;..\..\components\libc\compilers\common\none-gcc;Libraries\CMSIS\KEIL_CORE;Libraries\MM32F103\Include;Libraries\MM32F103\Source;Libraries\MM32F103\HAL_lib\inc;..\..\examples\utest\testcases\kernel
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  scatter file: .\drivers\linker_scripts\link.sct
  group Applications
    applications/: main.c
  group CPU
    ../../libcpu/arm/common/: showmem.c div0.c backtrace.c
    ../../libcpu/arm/cortex-m3/: cpuport.c context_rvds.S
  group DeviceDrivers
    ../../components/drivers/misc/: pin.c
    ../../components/drivers/serial/: serial.c
    ../../components/drivers/src/: dataqueue.c waitqueue.c ringblk_buf.c workqueue.c ringbuffer.c pipe.c completion.c
  group Drivers
    drivers/: drv_gpio.c drv_uart.c board.c
  group finsh
    ../../components/finsh/: finsh_vm.c msh.c finsh_parser.c cmd.c finsh_node.c shell.c finsh_var.c finsh_compiler.c finsh_heap.c finsh_ops.c finsh_error.c finsh_token.c finsh_init.c
  group Kernel
    ../../src/: memheap.c device.c object.c mem.c clock.c scheduler.c thread.c timer.c irq.c components.c kservice.c idle.c ipc.c mempool.c
  group libc
    ../../components/libc/compilers/common/: time.c
  group Libraries
    Libraries/MM32F103/HAL_lib/src/: HAL_rtc.c HAL_bkp.c HAL_spi.c HAL_flash.c HAL_exti.c HAL_tim.c HAL_i2c.c HAL_uart.c HAL_adc.c HAL_wwdg.c HAL_iwdg.c HAL_dma.c HAL_rcc.c HAL_pwr.c HAL_misc.c HAL_gpio.c HAL_crc.c HAL_can.c
    Libraries/MM32F103/Source/: system_MM32F103.c
    Libraries/MM32F103/Source/KEIL_StartAsm/: startup_MM32F103.s
